Commit message: Manipulation Engine

File: mengine/assets/plane/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=5000 5000 10; visual mesh filename=plane.obj scale=1 1 1
